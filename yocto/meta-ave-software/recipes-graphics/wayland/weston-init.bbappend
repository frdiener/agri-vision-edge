FILESEXTRAPATHS:prepend := "${THISDIR}/weston-init:"
