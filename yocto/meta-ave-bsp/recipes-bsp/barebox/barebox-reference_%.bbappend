FILESEXTRAPATHS:prepend := "${THISDIR}/barebox-reference:"
